# Keil uVision project blink_led_LP_MSPM0G3507_freertos_keil.uvprojx, settings and files
target blink_led_LP_MSPM0G3507_freertos_keil (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blink_led_LP_MSPM0G3507_freertos_keil +hex
  BeforeMake: cmd.exe /C "$P..\..\syscfg.bat  '$P' blink_led.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../../kernel/freertos/Source/include;../../../../../../../source;../../../../../../../kernel/freertos/Source/portable/GCC/ARM_CM0;../../../../../../../kernel/freertos/builds/LP_MSPM0G3507/release;..\..\freertos;..\..\BSP;..\..\APP;..\..\SEGGER\RTT;..\..\SEGGER\Config;..\..\SEGGER\log;..\..\..\blink_led1_pwm;..\..\source\third_party\CMSIS\Core\Include;..\..\kernel\freertos\Source\include;..\..\source;..\..\kernel\freertos\Source\portable\GCC\ARM_CM0;..\..\kernel\freertos\builds\LP_MSPM0G3507\release;..\..\..\electric-competition-training
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../../: main.c main-blinky.c blink_led.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c board.h
    ./: startup_mspm0g350x_uvision.s
  group Driverlib
    D:/Code/ElectricCompetitionProject/electric-competition-training/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group FreeRTOS Library
    D:/Code/ElectricCompetitionProject/electric-competition-training/kernel/freertos/builds/LP_MSPM0G3507/release/keil/Objects/: freertos_builds_LP_MSPM0G3507_release_keil.lib
  group LOG
    ../../SEGGER/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
    ../../SEGGER/log/: bsp_log.c
  group BSP
    ../../BSP/: OLED.c OLED.h oledfont.h OLED_Data.c OLED_Data.h KEY.c KEY.h trace.c trace.h misc.c misc.h PID.c PID.h dwt.c dwt.h daemon.c daemon.h menu.h menu.c fifo.c fifo.h ZDT_Motor.c ZDT_Motor.h K230.c K230.h icm42688.c icm42688.h No_Mcu_Ganv_Grayscale_Sensor.c No_Mcu_Ganv_Grayscale_Sensor_Config.h encoder_timer.c encoder_timer.h encoder.c encoder.h dcmotor.c dcmotor.h IMU.c IMU.h
  group APP
    ../../APP/: Robot_Cmd.c Robot_Cmd.h Chassis.c Chassis.h Robot.c Robot.h Gimbal.c Gimbal.h
