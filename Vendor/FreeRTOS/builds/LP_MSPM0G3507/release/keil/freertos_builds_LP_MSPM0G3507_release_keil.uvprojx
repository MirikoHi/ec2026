# Keil uVision project freertos_builds_LP_MSPM0G3507_release_keil.uvprojx, settings and files
target freertos_builds_LP_MSPM0G3507_release_keil (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos_builds_LP_MSPM0G3507_release_keil +hex (library)
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __MSPM0G3507__
  c include: ..\..\..\..\..\..;..\..\..\..\..\mspm0_sdk;..\..\..\..\..\mspm0_sdk\third_party\CMSIS\Core\Include;..\..\..\..\Source\include;..\..\..\..\Source\portable\TI_ARM_CLANG\ARM_CM0;..\..\..\..;..\..\..\..\..\SYSVIEWFreeRTOSV11\FreeRTOSV11;..\..\..\..\..\SYSVIEWFreeRTOSV11\SYSVIEW;..\..\..\..\..\SYSVIEWFreeRTOSV11\SEGGER;..\..\..\..\..\SYSVIEWFreeRTOSV11\Config;..\..\..\..\..\SEGGER\RTT;..\..\..\..\..\SEGGER\Config
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  group Header files
    ../../../../: FreeRTOSConfig.h
  group Source files
    ../../../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Source/portable/MemMang/: heap_4.c
    ../../../../Source/portable/TI_ARM_CLANG/ARM_CM0/: port.c portasm.c
    ../../../../dpl/: AppHooks_freertos.c ClockP_freertos.c DebugP_freertos.c MutexP_freertos.c SemaphoreP_freertos.c SystemP_freertos.c StaticAllocs_freertos.c TaskP_freertos.c HwiPMSPM0_freertos.c
    ../../../../../target/keil/: startup_mspm0g350x_uvision.s
